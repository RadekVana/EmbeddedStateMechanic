<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\NC232_tests.ewp</path>
    </project>
    <batchBuild />
</workspace>
