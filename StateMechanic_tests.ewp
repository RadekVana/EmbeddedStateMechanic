# IAR project StateMechanic_tests.ewp, settings and files
configuration Debug (V850, debug)
  General.GMemoryModel: 1
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl85nn1.h
  General.GHeapSize: 4096
  General.GDeviceSelect: 70F3375 V850ES - uPD70F3375
  ICCV850.PreInclude: _preinclude\preinclude.h
  ICCV850.CCIncludePath2: My_utils\; Unity-master\src\; UnitTypes\; UnitArrays\; StateMechanic\; StateMechanic\Event\; StateMechanic\EvHandler\; StateMechanic\Info\; StateMechanic\State\; StateMechanic\Transition\; StateMechanic\TransitionGuards\; __TESTS\StateMechanic\; __TESTS\StateMechanic\MockObjects\; __TESTS\StateMechanic\Event\; __TESTS\StateMechanic\EvHandler\; __TESTS\StateMechanic\Info\; __TESTS\StateMechanic\State\; __TESTS\StateMechanic\Transition\; __TESTS\StateMechanic\TransitionGuards\; __TESTS\MemoryTest\
  ICCV850.CCOptLevel: 0
  ICCV850.CCOptStrategy: 1
  ICCV850.IccLang: 1
  AV850.ADefines: CODE_MODEL_NORMAL; DATA_MODEL_SMALL
  AV850.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk70f3375.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ./: main.cpp
  group __TESTS/MemoryTest
    __TESTS/MemoryTest/: memTest.cpp
  group __TESTS/StateMechanic
    __TESTS/StateMechanic/: _testEventHandlers.cpp _testStateMechanic.cpp
  group __TESTS/StateMechanic/Event
    __TESTS/StateMechanic/Event/: _testAbstractEvents.cpp _testEvents.cpp
  group __TESTS/StateMechanic/EvHandler
    __TESTS/StateMechanic/EvHandler/: _testEvHandler.cpp
  group __TESTS/StateMechanic/Info
    __TESTS/StateMechanic/Info/: _testFiredData.cpp _testInfo.cpp
  group __TESTS/StateMechanic/MockObjects
    __TESTS/StateMechanic/MockObjects/: MockEvent.hpp MockEvHandler.hpp MockFullEvent.hpp MockInfo.cpp MockState.hpp MockStateMachine.hpp MockStateWithMachineRef.hpp MockStruct.hpp MockTransition.hpp
  group __TESTS/StateMechanic/State
    __TESTS/StateMechanic/State/: _testState.cpp
  group __TESTS/StateMechanic/Transition
    __TESTS/StateMechanic/Transition/: _testTransition.cpp
  group __Unity
    Unity-master/src/: unity.c unity.h unity_internals.h
  group _preinclude
    _preinclude/: preinclude.c
  group My_utils
    My_utils/: __BUILD_SETTINGS__.h my_string.h MyFunctionoid.c MySorting.c SmartEnum.c struct_cmp.h
  group StateMechanic
    StateMechanic/: StateMechanic.cpp
  group StateMechanic/Event
    StateMechanic/Event/: AbstractEvents.cpp Event.cpp EventTemplate.hpp IEvent.hpp
  group StateMechanic/EvHandler
    StateMechanic/EvHandler/: EvHandler.hpp IEvHandler.hpp
  group StateMechanic/Info
    StateMechanic/Info/: FiredData.hpp IFiredData.hpp IInfo.hpp InfoTemplate.hpp
  group StateMechanic/State
    StateMechanic/State/: IState.hpp IStateWithMachineRef.hpp State.cpp
  group StateMechanic/Transition
    StateMechanic/Transition/: AbstractTransition.cpp ITransition.hpp Transition.cpp
  group StateMechanic/TransitionGuards
    StateMechanic/TransitionGuards/: ITransitionGuard.hpp TransitionGuard.hpp TransitionGuardTemplate.hpp
