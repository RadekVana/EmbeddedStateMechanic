<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>Debug</name>
        <toolchain>
            <name>V850</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>13</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>CInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CProcessor</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DynDriver</name>
                    <state>SIMV850</state>
                </option>
                <option>
                    <name>GoToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GoToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>MacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>MemOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MemFile</name>
                    <state>$TOOLKIT_DIR$\CONFIG\DDF\io70f3375.ddf</state>
                </option>
                <option>
                    <name>CMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DDDFileSlave</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CSpyExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CSpyExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse3</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E1NWIV850</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E1NWIMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1NWISuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1NWIVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1NWIEraseFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1NWIMINICUBESpeed</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1nwiDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1nwiLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E20V850</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E20NWIMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20NWISuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20NWIVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20NWIEraseFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20NWIMINICUBESpeed</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20nwiDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20nwiLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>IECV850</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>IECMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IECSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IECVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>IEC2E2RV850</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>IEC2E2RMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IEC2E2RSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IEC2E2RVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IEC2E2RDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IEC2E2RLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>MICV850</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>MICMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MICSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MICVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MICEraseFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MICMINICUBESpeed</name>
                    <state>1</state>
                </option>
                <option>
                    <name>MicDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MicLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>MIC2V850</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>MIC2Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MIC2SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MIC2VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MIC2EraseFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MIC2DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MIC2LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMV850</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>SIMMandatory</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>TKSV850</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>TKSMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKSSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKSVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TksDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TksLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>TksComPort</name>
                    <version>0</version>
                    <state>2</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
                <loadFlag>1</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\TargetAccessServer\TargetAccessServer.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
</project>
